# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Hardware\LED;..\Hardware\SYSCLK;..\Hardware\GPIOConfig;..\Hardware\Delay;..\Hardware\OLED
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/SYSCLK/: SYSCLK.c
    ../Hardware/GPIOConfig/: GPIOConfig.c
    ../Hardware/Delay/: Delay.c
    ../Hardware/OLED/: oled.c
  group User
    ../User/: main.c
